require recipes-bsp/u-boot/u-boot-hach.inc
