BOARD_colibri-imx7-emmc = "colibri-imx7-emmc"
BOARD_colibri-imx7-emmc-1370 = "colibri-imx7-emmc"
PACKAGECONFIG_colibri-imx7-emmc = "allboardconfigs enableboardconfig python"
PACKAGECONFIG_colibri-imx7-emmc-1370 = "allboardconfigs enableboardconfig python"
